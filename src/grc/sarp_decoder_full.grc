options:
  parameters:
    author: Tom Mladenov
    copyright: Tom Mladenov
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: LEOSAR Receiver
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    gui_hint: (3, 1, 1, 1)
    label: RRC filter alpha
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.01'
    stop: '3.0'
    value: '0.4'
  states: {}
- name: bitrate
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '1544500000'
  states: {}
- name: clock_alpha
  id: variable_qtgui_range
  parameters:
    gui_hint: (4, 1, 1, 1)
    label: Clock Alpha
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '0.8'
    value: '0.02'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: filename_sarp
  id: variable
  parameters:
    value: '"sarp_symbols_" + str(time.time()) +".u8"'
  states: {}
- name: filename_sarr
  id: variable
  parameters:
    value: '"sarr_baseband_" + str(time.time()) +"_" + str(int(samprate/4)) + "ksps.cf32"'
  states: {}
- name: gaussian_taps
  id: variable
  parameters:
    value: firdes.gaussian (1.5, 2* (samprate/ symrate) , 0.5, 12)
  states: {}
- name: max_clock_offset
  id: variable
  parameters:
    value: '100e-6'
  states: {}
- name: max_freq_dev
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: '361'
  states: {}
- name: pll_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: (5, 1, 1, 1)
    label: PLL Loop Bandwidth
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.0001'
    stop: '0.1'
    value: '0.0047'
  states: {}
- name: recpath
  id: variable
  parameters:
    value: '""'
  states: {}
- name: samprate
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: float(samprate)/(symrate)/decimation
  states: {}
- name: symrate
  id: variable
  parameters:
    value: 2*bitrate
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0.5'
    max_gain: '5000'
    rate: '10e-3'
    reference: '0.5'
    type: complex
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 2*cmath.pi*(float(max_freq_dev)/samprate)
    min_freq: '-2*cmath.pi*(float(max_freq_dev)/samprate)'
    w: pll_loop_bw
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-170000'
    offset: '0'
    phase: '0'
    samp_rate: samprate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: decimation
    gain: '1'
    high_cutoff_freq: '4000'
    low_cutoff_freq: '400'
    samp_rate: samprate
    type: fir_filter_fff
    width: '150'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: recpath + filename_sarp
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: recpath + filename_sarr
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/tom/workspace/SDRSharp_20161031_094324Z_1544478984Hz_IQ.cf32
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samprate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.2'
    gain_omega: clock_alpha**2/4.0
    mu: '0.5'
    omega: sps*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '011001010101100110011010100110100101011010101010'
    tagname: 0x42BB1F (diff encoded)
    threshold: '0'
    type: byte
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: gaussian_taps
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: note_0
  id: note
  parameters:
    note: 170 kHz offset
  states: {}
- name: note_1_0_1
  id: note
  parameters:
    note: 1200 symbols
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samprate/decimation
    fc: '0'
    fftsize: '1024'
    gui_hint: (2,0,1,1)
    label1: Inphase
    label2: Quadrature
    name: '"SARP PLL Downconverted PDS"'
    nconnections: '2'
    type: float
    update_time: '0.001'
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samprate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: (0, 0, 1, 2)
    label1: IQ input
    name: '"RF Input"'
    showports: 'True'
    type: complex
    update_time: '0.001'
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: (2, 1, 1, 1)
    label1: Symbols
    legend: 'False'
    marker1: '0'
    name: '"PDS Recovered Soft Symbols"'
    size: '1024'
    srate: samprate/decimation
    style1: '0'
    type: float
    update_time: '0.03'
    width1: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (2, 2, 1, 1)
    label1: ''
    legend: 'False'
    name: '"PDS Synchronised Hard Symbols"'
    size: '128'
    srate: '4800'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"0x42BB1F (diff encoded)"'
    type: float
    update_time: '0.03'
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samprate/4
    fc: '170000'
    fftsize: '2048'
    gui_hint: (0, 2, 1, 1)
    int_max: '-10'
    int_min: '-100'
    label1: Input
    name: '"SARR 406 MHz Transponder Passband"'
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: num_taps
    samp_rate: samprate/decimation
    sym_rate: symrate
    type: fir_filter_fff
  states: {}
- name: satellites_fixedlen_tagger_0
  id: satellites_fixedlen_tagger
  parameters:
    packet_len: '1200'
    packetlen_tag: packet_len
    stream_type: byte
    syncword_tag: 0x42BB1F (diff encoded)
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Symbols
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: phase
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: tracked
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: Symbols
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: phase
  states: {}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: tracked
  states: {}
- name: virtual_source_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: tracked
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:38211
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_arg_0, '0']
- [analog_agc_xx_0, '0', virtual_sink_1_0, '0']
- [analog_pll_carriertracking_cc_0, '0', analog_agc_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_complex_to_arg_0, '0', virtual_sink_1, '0']
- [blocks_complex_to_float_0, '0', rational_resampler_xxx_1, '0']
- [blocks_complex_to_float_0, '1', rational_resampler_xxx_1_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_pdu_to_tagged_stream_1, '0', blocks_file_sink_0_0, '0']
- [blocks_pdu_to_tagged_stream_1, '0', zeromq_pub_sink_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_pdu_to_tagged_stream_1, pdus]
- [blocks_throttle_0, '0', analog_pll_carriertracking_cc_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_binary_slicer_fb_0_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', virtual_sink_0_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', satellites_fixedlen_tagger_0, '0']
- [fir_filter_xxx_0, '0', band_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', blocks_file_sink_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_1_0, '0', qtgui_freq_sink_x_0, '1']
- [root_raised_cosine_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [satellites_fixedlen_tagger_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [virtual_source_2, '0', digital_binary_slicer_fb_0_0, '0']
- [virtual_source_2_0, '0', fir_filter_xxx_0, '0']
- [virtual_source_2_0_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_2_0_0_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
